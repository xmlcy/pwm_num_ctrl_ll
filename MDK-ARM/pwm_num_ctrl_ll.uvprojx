# Keil uVision project pwm_num_ctrl_ll.uvprojx, settings and files
target pwm_num_ctrl_ll (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: pwm_num_ctrl_ll +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User\Driver\inc;..\User\Main\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_exti.c stm32f1xx_ll_tim.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/Driver
    ../User/Driver/: user_pwm.c
  group User/Main
    ../User/Main/: user_main.c
software components: CMSIS:CORE 4.3.0
